// C++ code
//
int i;
byte bt, j, p[7]={13,12,11,10,9,8,7};
byte cn[16][7]={
	{0,0,0,0,0,0,1},
	{1,0,0,1,1,1,1},
    {0,0,1,0,0,1,0},
    {0,0,0,0,1,1,0},
    {1,0,0,1,1,0,0},
    {0,1,0,0,1,0,0},
    {0,1,0,0,0,0,0},
    {0,0,0,1,1,0,1},
    {0,0,0,0,0,0,0},
    {0,0,0,1,1,0,0},
    {0,0,0,1,0,0,0},
    {1,1,0,0,0,0,0},
    {0,1,1,0,0,0,1},
    {1,0,0,0,0,1,0},
    {0,1,1,0,0,0,0},
    {0,1,1,1,0,0,0}
};
void setup()
{
  for(i=0;i<7;i++){
    pinMode(p[i],OUTPUT);
  }
  pinMode(6,INPUT_PULLUP);
}

void loop()
{
  for(i=0;i<16000;i++){
    bt = digitalRead(6);
    if(bt == HIGH){
      for(j=0;j<7;j++){
        digitalWrite(p[j],cn[i/1000][j]);
      }
    }
    else {
      for(j=0;j<7;j++){
        digitalWrite(p[j],1);
      }
    }
    delay(1);
  }
}